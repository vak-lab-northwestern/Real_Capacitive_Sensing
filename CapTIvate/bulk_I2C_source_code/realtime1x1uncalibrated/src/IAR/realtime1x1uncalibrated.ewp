# IAR project realtime1x1uncalibrated.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xllfn.h
  General.OGChipSelectMenu: MSP430FR2676 MSP430FR2676
  General.GStackSize2: 256
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: TARGET_IS_MSP430FR2676; TARGET_IS_MSP430FR2XX_4XX
  ICC430.newCCIncludePaths: ../; ../captivate; ../captivate/ADVANCED; ../captivate/BASE; ../captivate/COMM; ../captivate_app; ../captivate_config; ../driverlib/MSP430FR2xx_4xx; ../driverlib
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$/config/lnk430fr2676.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.newCCIncludePaths: ../; ../captivate; ../captivate/ADVANCED; ../captivate/BASE; ../captivate/COMM; ../captivate_app; ../captivate_config; ../driverlib/MSP430FR2xx_4xx
  ICC430.CCOptStrategy: 0
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../: main.c
  group captivate
    ../captivate/: captivate.h
  group captivate/ADVANCED
    ../captivate/ADVANCED/: CAPT_Manager.h CAPT_Trackpad.h CAPT_EMC.h CAPT_Buttons.h CAPT_Manager.c CAPT_Calibration.h CAPT_Slider.h
  group captivate/BASE
    ../captivate/BASE/: CAPT_Type.h rom_captivate.h CAPT_ISR.c rom_map_captivate.h CAPT_HAL.h CAPT_Touch.h
  group captivate/BASE/rom_headers
    ../captivate/BASE/rom_headers/: rom_captivate_msp430fr2522_family.h rom_captivate_msp430fr2633_family.h rom_captivate_msp430fr2676_family.h
  group captivate/COMM
    ../captivate/COMM/: CAPT_PingPongBuffer.h FunctionTimer.c CAPT_Interface.c I2CSlave_Definitions.h I2CSlave.h CAPT_Protocol.h CAPT_ByteQueue.h UART.h FunctionTimer.h CAPT_Interface.h FunctionTimer_Definitions.h I2CSlave.c CAPT_CommConfig.h UART_Definitions.h UART.c
  group captivate_app
    ../captivate_app/: CAPT_App.c CAPT_BSP.h CAPT_App.h CAPT_BSP.c
  group captivate_config
    ../captivate_config/: CAPT_UserConfig.c CAPT_UserConfig.h
  group driverlib/MSP430FR2xx_4xx
    ../driverlib/MSP430FR2xx_4xx/: timer_a.h adc.h wdt_a.h sac.h ecomp.h eusci_a_uart.h eusci_b_i2c.h eusci_a_spi.h tia.h mpy32.h icc.h timer_b.h crc.h lcd_e.h eusci_b_spi.h rom_driverlib.h framctl.h sfr.h rom_map_driverlib.h pmm.h gpio.h sysctl.h rtc.h driverlib.h cs.h tlv.h
  group driverlib/MSP430FR2xx_4xx/inc
    ../driverlib/MSP430FR2xx_4xx/inc/: version.h hw_memmap.h
  group driverlib/MSP430FR2xx_4xx/rom_headers
    ../driverlib/MSP430FR2xx_4xx/rom_headers/: rom_driverlib_fr235x.h rom_driverlib_fr253x_fr263x.h rom_driverlib_fr2676.h
  group mathlib
    ../mathlib/: QmathLib.h IQmathLib.h
  group objects
    ../captivate/BASE/libraries/: captivate_fr2676_family.r43
    ../driverlib/MSP430FR2xx_4xx/libraries/: driverlib_fr2676_family.r43
    ../mathlib/libraries/: QmathLib_IAR_MPY32_5xx_6xx_CPUX_large_code_large_data.r43 IQmathLib_IAR_MPY32_5xx_6xx_CPUX_large_code_large_data.r43
